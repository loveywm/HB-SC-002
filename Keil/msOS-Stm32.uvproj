# Keil uVision project msOS-Stm32.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HB-SC-002 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SourceFile\App;..\SourceFile\System;..\SourceFile\System\Device;..\SourceFile\System\Device\Drive;..\SourceFile\System\Device\Drive\CMSIS;..\SourceFile\System\Device\Drive\LIB\inc;..\SourceFile\System\OS;..\SourceFile\System\OS\msOS;..\SourceFile\System\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../SourceFile/App/: app.c Uart.c Proc.c
  group System
    ../SourceFile/System/: system.h system.c
  group System.Device
    ../SourceFile/System/Device/: device.c device.h device_key.c device_rtc.c device_timer.c device_io.c device_adc.c device_usart.c device_systick.c
  group System.Device.Drive
    ../SourceFile/System/Device/Drive/: drive.h stm32f10x_it.c
  group System.Device.Drive.Cmsis
    ../SourceFile/System/Device/Drive/CMSIS/: core_cm3.c system_stm32f10x.c
    ../SourceFile/System/Device/Drive/CMSIS/STARTUP/: startup_stm32f10x_md.s
  group System.Device.Drive.Lib
    ../SourceFile/System/Device/Drive/LIB/src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_adc.c
